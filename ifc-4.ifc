Properties of the parts of a building model (IFC4)

# File
Description: Externe Antenne für Mehrkanalaktoren, Aufputz superflach, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BN990003, Externe Antenne für Mehrkanalaktoren, Aufputz superflach
In: Raum
Description: Externe Antenne zur Empfangsverbesserung bei schwierigen Empfangsbedingungen der Mehrkanalaktoren (Antennenkabel JZ-26 gehört nicht zum Lieferumfang).; Classification: EC011308 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BN990003; ModelLabel: JZ-25; GlobalTradeItemNumber: 4050528015686; ProductURL: https://alre.de/produkt_BN990003
Pset_Specification - NominalLength: 0.0785 m; NominalWidth: 0.078 m; NominalDepth: 0.0139 m; NetWeight: 0.043
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: Antenne; Zubehör: yes; ETIM-Klasse: EC011308; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BN990003.pdf
